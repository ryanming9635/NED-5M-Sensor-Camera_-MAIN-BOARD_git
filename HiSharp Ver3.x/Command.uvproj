# Keil uVision project Command.uvproj, settings and files
target Target 1 (MCS-51)
  device: MPC82G516 Megawin
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM (0-0x3FF) CLOCK(24000000)
  output: NED_5MCMOS_v0_a_4_XXXX_20160303 +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 UART.c BusCtrl.c CommandShell.c Main.c OSD_Graph.c OSDAction .c OSDCtrl.c Timer.c TW28xx_Audio.c TW28xx_Video.c TW2835_Init.c NED.c
